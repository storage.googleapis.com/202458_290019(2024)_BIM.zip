Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 50356248-56fd-404e-bfe4-5503dd407272, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 290019(2024).ifc
Time: 2025-01-29T23:45:09
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level

# IfcFlowController: 290019(2024):290019 Wall coupling for shower hose, 290019(2024):290019 Wall coupling for shower hose:375065
In: Level 1
Type - PredefinedType: FAUCET; Material: Chrome
Type - General - Author: BIMStone; BIMObjectName: 290019(2024); ManufacturerName: Oras Group; ManufacturerURL: http://www.oras group.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - ETIM Class Number: EC010132 Hand shower holder; UNSPSC Class Number: 30181800 Faucet and shower heads, jets and parts and accessories; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/290019; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach
Type - Constraints - Default Elevation: 0 mm
Type - Mechanical - Additional Features: two-part construction; Backflow Prevention EN1717: EB; Connection: Direct connection;External thread; Connection Size: G1/2; Installation Type: Wall mounted; Max. Hot Water Supply: 80 C; Mechanical Parts: Non-return valve(s); Shower Parts: Wall connection elbow;Shower holder; Surface treatment: Chrome; Working Pressure: 50 - 1000 kPa
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Dimensions - NominalDepth: 82.7 mm; NominalHeight: 55.4 mm; NominalWidth: 45 mm
Type - Identity Data - 3D View: https://static.oras.com/3D/290019; Catalog Drawing URL: http://static.oras.com/catdrw/290019; Category B2B: Accessories; Category B2C: Shower solutions; Color variants: 290019-33;290019-80;290019-81; Dimension Drawing URL: http://static.oras.com/dimdrw/290019; FDV Document URL: http://www.oras.com/datasheet/290019/en/fdv; Group: Wall coupling for shower hose; Installation and Maintenance Guide URL: http://static.oras.com/manual/290019; Interactive AR View URL: https://static.oras.com/AR/290019; Manufacturer: Oras Group; Market: International;Poland;Estonia;Lithuania;Latvia;Germany;Austria;Switzerland;Belgium;Netherlands;Czech Republic;Slovakia;Italy; Mobile Product Information URL: http://mpi.oras.com/290019; Model: 290019 Wall coupling for shower hose; Name_en: 290019 Wall coupling for shower hose; OmniClass Number: 23.45.55.00; Product Code: 290019; Product Family: Oras Group; Product Image URL: http://static.oras.com/image/290019; Product URL: http://static.oras.com/290019; Technical DataSheet URL: http://www.oras.com/datasheet/290019/en; Type Name: 290019 Wall coupling for shower hose; Warranty Information URL: http://warranty.oras.com
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras Group; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 290019(2024); Features: n/a; Finish: Polished; Grade: n/a; Material: Brass/Plastic; ModelNumber: n/a; ModelReference: 290019; Name: 290019 Wall coupling for shower hose; ReplacementCost: n/a; Shape: Sculptured; Size: 95 x 60 x 245 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 290019; Manufacturer: Oras Group
Type - Pset_ProductRequirements - Name: 290019 Wall coupling for shower hose
Type - Pset_ValveTypeCommon - ValvePattern: OTHER; ValveOperation: OTHER; ValveMechanism: OTHER; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 290019 Wall coupling for shower hose; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Phasing - Phase Created: New Construction
Construction - Type: 0 mm
Dimensions - Area: 0.010793 m2; Volume: 0.000206105 m3
Identity Data - Mark: 12
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 290019(2024); Family and Type: 290019(2024): 290019 Wall coupling for shower hose; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 290019 Wall coupling for shower hose; Type Id: 375042; WarrantyStartDate: n/a
